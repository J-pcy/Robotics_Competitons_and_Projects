# Keil uVision project but.uvprojx, settings and files
target but (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: but
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\User;..\uCOS-III;..\uCOS-III\App;..\uCOS-III\Cfg;..\uCOS-III\Ports;..\uCOS-III\Source;..\uCOS-III\uC-CPU;..\uCOS-III\uC-LIB;..\CPAL;..\AHRS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c user.c user.h irq.c
  group APP
    ../APP/: app.c app.h app_led.c app_ahrs.c
  group BSP
    ../BSP/: bsp.c bsp.h bsp_led.c bsp_led.h bsp_i2c.h bsp_i2c.c bsp_timer4.c bsp_timer4.h bsp_i2c1_soft.c bsp_i2c1_soft.h bsp_i2c2_soft.c bsp_i2c2_soft.h bsp_usart.c bsp_usart.h bsp_flash.c bsp_flash.h
  group AHRS
    ../AHRS/: ahrs.c ahrs.h ahrs_mpu6050.c ahrs_mpu6050.h ahrs_hmc5883l.c ahrs_hmc5883l.h ahrs_imu.c ahrs_imu.h
  group uCOS-III\APP
    ../uCOS-III/App/: app_cfg.h os_cfg.h os_cfg_app.h
  group uCOS-III\Cfg
    ../uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uCOS-III\Ports
    ../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-III\Source
    ../uCOS-III/Source/: os_var.c os_type.h os_tmr.c os_time.c os_tick.c os_task.c os_stat.c os_sem.c os_q.c os_prio.c os_pend_multi.c os_mutex.c os_msg.c os_mem.c os_int.c os_flag.c os_dbg.c os_core.c os_cfg_app.c os.h
  group uCOS-III\CPU
    ../uCOS-III/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cfg.h cpu_core.c cpu_core.h cpu_def.h
  group uCOS-III\LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_cfg.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
